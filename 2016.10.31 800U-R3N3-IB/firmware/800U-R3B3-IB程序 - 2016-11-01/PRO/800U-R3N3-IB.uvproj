# Keil uVision project 800U-R3N3-IB.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F300 Silicon Labs
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(25000000)
  output: 800U-R3N3-IB +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\INC
  group Source Group 1
    ./: STARTUP.A51
  group INC
    ../INC/: adc.h C8051F300.H delay.h DWG.h exti.h include.h init.h key.h led.h main.h timer.h uart.h rs485.h flash.h process.h crc.h
  group SRC
    ../SRC/: adc.c delay.c DWG.c exti.c init.c key.c led.c main.c timer.c uart.c rs485.c flash.c process.c crc.c
