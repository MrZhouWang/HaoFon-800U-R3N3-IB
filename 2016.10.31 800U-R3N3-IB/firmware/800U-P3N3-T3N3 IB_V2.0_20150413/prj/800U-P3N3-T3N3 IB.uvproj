# Keil uVision project 800U-P3N3-T3N3 IB.uvproj, settings and files
target Target 1 (MCS-51)
  device: SM8954A SyncMOS
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0x3FFF) CLOCK(40000000)
  output: 800U-T3N3 IB_V2.0_20140409 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../src/: CBM7008.C crc.c eeprom.c key.c led.c main.c process.c uart.c
